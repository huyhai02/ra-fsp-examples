# IAR project ethernet_ns_ek_ra8d1_ep.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: R7FA8D1BH Renesas R7FA8D1BH
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 65
  General.FPU2: 7
  ICCARM.CCDefines: _RA_CORE=CM85; _RA_TZ_NONSECURE; _RENESAS_RA_; _RA_ORDINAL=2
  ICCARM.IExtraOptions: -f "xcl/rasc_iccarm"
  ICCARM.CCIncludePath2: ra/arm/CMSIS_5/CMSIS/Core/Include; ra/aws/FreeRTOS/FreeRTOS-Plus/Source/FreeRTOS-Plus-TCP/source/include; ra/aws/FreeRTOS/FreeRTOS/Source/include; ra/fsp/inc; ra/fsp/inc/api; ra/fsp/inc/instances; ra/fsp/src/rm_freertos_plus_tcp; ra/fsp/src/rm_freertos_port; ra_cfg/aws; ra_cfg/fsp_cfg; ra_cfg/fsp_cfg/bsp; ra_gen; src; $PROJ_DIR$
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: _RA_CORE=CM85; _RA_TZ_NONSECURE; _RENESAS_RA_; _RA_ORDINAL=2
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: ethernet_ns_ek_ra8d1_ep.hex
  ILINK.IlinkOutputFile: ethernet_ns_ek_ra8d1_ep.out
  ILINK.IlinkIcfFile: script/fsp.icf
  ILINK.IlinkExtraOptions: --config_search "$PROJ_DIR$"; -f "xcl/rasc_ilinkarm"
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG; _RA_CORE=CM85; _RA_TZ_NONSECURE; _RENESAS_RA_; _RA_ORDINAL=2
  ICCARM.IccLang: 0
  group (top)
    ./: buildinfo.ipcf
  group Flex Software/Build Configuration
    ra_cfg/fsp_cfg/bsp/: board_cfg.h bsp_cfg.h bsp_mcu_device_cfg.h bsp_mcu_device_pn_cfg.h bsp_mcu_family_cfg.h bsp_mcu_ofs_cfg.h bsp_pin_cfg.h
    ra_cfg/aws/: FreeRTOSConfig.h FreeRTOSIPConfig.h
    ra_cfg/fsp_cfg/: r_ether_cfg.h r_ether_phy_cfg.h r_ioport_cfg.h
  group Flex Software/Components/arm
    ra/arm/CMSIS_6/CMSIS/Core/Include/m-profile/: armv7m_cachel1.h armv7m_mpu.h armv81m_pac.h armv8m_mpu.h armv8m_pmu.h cmsis_armclang_m.h cmsis_clang_m.h cmsis_gcc_m.h cmsis_iccarm_m.h cmsis_tiarmclang_m.h
    ra/arm/CMSIS_6/CMSIS/Core/Include/: cmsis_armclang.h cmsis_clang.h cmsis_compiler.h cmsis_gcc.h cmsis_version.h core_ca.h core_cm0.h core_cm0plus.h core_cm1.h core_cm23.h core_cm3.h core_cm33.h core_cm35p.h core_cm4.h core_cm52.h core_cm55.h core_cm7.h core_cm85.h core_sc000.h core_sc300.h core_starmc1.h tz_context.h
    ra/arm/CMSIS_6/CMSIS/Core/Include/a-profile/: cmsis_armclang_a.h cmsis_clang_a.h cmsis_cp15.h cmsis_gcc_a.h cmsis_iccarm_a.h irq_ctrl.h
    ra/arm/CMSIS_6/CMSIS/Core/Include/r-profile/: cmsis_armclang_r.h cmsis_clang_r.h cmsis_gcc_r.h
    ra/arm/CMSIS_6/: LICENSE
  group Flex Software/Components/aws
    ra/aws/FreeRTOS/FreeRTOS/Source/include/: atomic.h croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h newlib-freertos.h picolibc-freertos.h portable.h projdefs.h queue.h semphr.h stack_macros.h stream_buffer.h task.h timers.h
    ra/aws/FreeRTOS/FreeRTOS-Plus/Source/FreeRTOS-Plus-TCP/source/portable/BufferManagement/: BufferAllocation_2.c
    ra/aws/FreeRTOS/FreeRTOS/Source/: event_groups.c LICENSE.md list.c queue.c stream_buffer.c tasks.c timers.c
    ra/aws/FreeRTOS/FreeRTOS-Plus/Source/FreeRTOS-Plus-TCP/source/: FreeRTOS_ARP.c FreeRTOS_BitConfig.c FreeRTOS_DHCP.c FreeRTOS_DHCPv6.c FreeRTOS_DNS.c FreeRTOS_DNS_Cache.c FreeRTOS_DNS_Callback.c FreeRTOS_DNS_Networking.c FreeRTOS_DNS_Parser.c FreeRTOS_ICMP.c FreeRTOS_IP.c FreeRTOS_IP_Timers.c FreeRTOS_IP_Utils.c FreeRTOS_IPv4.c FreeRTOS_IPv4_Sockets.c FreeRTOS_IPv4_Utils.c FreeRTOS_IPv6.c FreeRTOS_IPv6_Sockets.c FreeRTOS_IPv6_Utils.c FreeRTOS_ND.c FreeRTOS_RA.c FreeRTOS_Routing.c FreeRTOS_Sockets.c FreeRTOS_Stream_Buffer.c FreeRTOS_TCP_IP.c FreeRTOS_TCP_IP_IPv4.c FreeRTOS_TCP_IP_IPv6.c FreeRTOS_TCP_Reception.c FreeRTOS_TCP_State_Handling.c FreeRTOS_TCP_State_Handling_IPv4.c FreeRTOS_TCP_State_Handling_IPv6.c FreeRTOS_TCP_Transmission.c FreeRTOS_TCP_Transmission_IPv4.c FreeRTOS_TCP_Transmission_IPv6.c FreeRTOS_TCP_Utils.c FreeRTOS_TCP_Utils_IPv4.c FreeRTOS_TCP_Utils_IPv6.c FreeRTOS_TCP_WIN.c FreeRTOS_Tiny_TCP.c FreeRTOS_UDP_IP.c FreeRTOS_UDP_IPv4.c FreeRTOS_UDP_IPv6.c
    ra/aws/FreeRTOS/FreeRTOS-Plus/Source/FreeRTOS-Plus-TCP/source/include/: FreeRTOS_ARP.h FreeRTOS_BitConfig.h FreeRTOS_DHCP.h FreeRTOS_DHCPv6.h FreeRTOS_DNS.h FreeRTOS_DNS_Cache.h FreeRTOS_DNS_Callback.h FreeRTOS_DNS_Globals.h FreeRTOS_DNS_Networking.h FreeRTOS_DNS_Parser.h FreeRTOS_ICMP.h FreeRTOS_IP.h FreeRTOS_IP_Common.h FreeRTOS_IP_Private.h FreeRTOS_IP_Timers.h FreeRTOS_IP_Utils.h FreeRTOS_IPv4.h FreeRTOS_IPv4_Private.h FreeRTOS_IPv4_Sockets.h FreeRTOS_IPv4_Utils.h FreeRTOS_IPv6.h FreeRTOS_IPv6_Private.h FreeRTOS_IPv6_Sockets.h FreeRTOS_IPv6_Utils.h FreeRTOS_ND.h FreeRTOS_Routing.h FreeRTOS_Sockets.h FreeRTOS_Stream_Buffer.h FreeRTOS_TCP_IP.h FreeRTOS_TCP_Reception.h FreeRTOS_TCP_State_Handling.h FreeRTOS_TCP_Transmission.h FreeRTOS_TCP_Utils.h FreeRTOS_TCP_WIN.h FreeRTOS_UDP_IP.h FreeRTOSIPConfigDefaults.h FreeRTOSIPDeprecatedDefinitions.h IPTraceMacroDefaults.h NetworkBufferManagement.h NetworkInterface.h
    ra/aws/FreeRTOS/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ra/aws/FreeRTOS/FreeRTOS-Plus/Source/FreeRTOS-Plus-TCP/source/portable/Compiler/GCC/: pack_struct_end.h pack_struct_start.h
  group Flex Software/Components/aws/FreeRTOS
    ra/aws/FreeRTOS/: LICENSE.md
  group Flex Software/Components/aws/IAR
    ra/aws/FreeRTOS/FreeRTOS-Plus/Source/FreeRTOS-Plus-TCP/source/portable/Compiler/IAR/: pack_struct_end.h pack_struct_start.h
  group Flex Software/Components/board
    ra/board/ra8d1_ek/: board.h board_ethernet_phy.h board_init.c board_init.h board_leds.c board_leds.h
  group Flex Software/Components/fsp
    ra/fsp/inc/api/: bsp_api.h fsp_common_api.h r_ether_api.h r_ether_phy_api.h r_ioport_api.h
    ra/fsp/src/bsp/mcu/all/: bsp_clocks.c bsp_clocks.h bsp_common.c bsp_common.h bsp_compiler_support.h bsp_delay.c bsp_delay.h bsp_exceptions.h bsp_group_irq.c bsp_group_irq.h bsp_guard.c bsp_guard.h bsp_io.c bsp_io.h bsp_ipc.c bsp_ipc.h bsp_irq.c bsp_irq.h bsp_macl.c bsp_macl.h bsp_mcu_api.h bsp_mmf.h bsp_module_stop.h bsp_ospi_b.c bsp_ospi_b.h bsp_register_protection.c bsp_register_protection.h bsp_sbrk.c bsp_sdram.c bsp_sdram.h bsp_security.c bsp_security.h bsp_tfu.h
    ra/fsp/src/bsp/mcu/ra8d1/: bsp_elc.h bsp_feature.h bsp_linker.c bsp_mcu_info.h bsp_override.h bsp_peripheral.h r_ospi_b_device_types.h
    ra/fsp/inc/: fsp_features.h fsp_version.h
    ra/fsp/src/rm_freertos_plus_tcp/: NetworkInterface.c pack_struct_end.h pack_struct_start.h
    ra/fsp/src/rm_freertos_port/: port.c portmacro.h
    ra/fsp/src/bsp/cmsis/Device/RENESAS/Include/: R7FA8D1BH.h renesas.h system.h
    ra/fsp/src/r_ether/: r_ether.c
    ra/fsp/inc/instances/: r_ether.h r_ether_phy.h r_ioport.h rm_freertos_plus_tcp.h
    ra/fsp/src/r_ether_phy/: r_ether_phy.c
    ra/fsp/src/r_ether_phy/targets/DP83620/: r_ether_phy_target_dp83620.c
    ra/fsp/src/r_ether_phy/targets/ICS1894/: r_ether_phy_target_ics1894.c
    ra/fsp/src/r_ether_phy/targets/KSZ8041/: r_ether_phy_target_ksz8041.c
    ra/fsp/src/r_ether_phy/targets/KSZ8091RNB/: r_ether_phy_target_ksz8091rnb.c
    ra/fsp/src/r_ioport/: r_ioport.c
    ra/fsp/src/bsp/cmsis/Device/RENESAS/Source/: startup.c system.c
  group Flex Software/Generated Data
    ra_gen/: bsp_clock_cfg.h common_data.c common_data.h hal_data.c hal_data.h main.c net_thread.c net_thread.h pin_data.c vector_data.c vector_data.h
  group Flex Software/Objects
    ./: secure.o
  group Flex Software/Program Entry
    src/: common_utils.h hal_entry.c net_thread_entry.c usr_app.h
    src/SEGGER_RTT/: SEGGER_RTT.c SEGGER_RTT.h SEGGER_RTT_Conf.h SEGGER_RTT_printf.c

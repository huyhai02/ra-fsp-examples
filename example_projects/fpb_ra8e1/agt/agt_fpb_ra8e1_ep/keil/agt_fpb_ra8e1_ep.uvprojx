# Keil uVision project agt_fpb_ra8e1_ep.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: R7FA8E1AF Renesas
  pack: Renesas.RA_DFP.5.6.0
  cpu: IRAM(0x22060000,0x80000) IRAM2(0x0,0x4000) IROM(0x02000000,0x00100000) XRAM(0x20000000,0x4000) CPUTYPE("Cortex-M85") FPU3(DFPU) DSP TZ MVE(FP) PACBTI CLOCK(12000000) ELITTLE
  output: agt_fpb_ra8e1_ep +hex
  AfterMake: cmd /c ""$Prasc_launcher.bat" "$Prasc_version.txt" -nosplash --launcher.suppressErrors --gensmartbundle --compiler ARMv6 --devicefamily ra "$Pconfiguration.xml" "$L%L" 2> "%%TEMP%%\rasc_stderr.out""
  c flags: Optim=3 v6Lang=3 v6LangP=3
  c misc: @via/rasc_armclang.via
  memory RVCT4: ROM 0x2000000 size 0x100000
  memory RVCT6: RAM 0x20000000 size 0x4000
  memory RVCT9: RAM 0x22060000 size 0x80000
  memory RVCT10: RAM 0x0 size 0x4000
  scatter file: .\script\fsp.scat
  link misc: --entry=Reset_Handler --no_startup --via=via/rasc_armlink.via
  group :Renesas RA Smart Configurator:Common Sources
    ./src/: hal_entry.c agt_ep.c agt_ep.h common_utils.h
    ./src/SEGGER_RTT/: SEGGER_RTT.c SEGGER_RTT.h SEGGER_RTT_Conf.h SEGGER_RTT_printf.c
software components: Flex Software:RA Configuration 1.0.0

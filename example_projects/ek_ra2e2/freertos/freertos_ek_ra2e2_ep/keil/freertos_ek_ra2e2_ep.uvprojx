# Keil uVision project freertos_ek_ra2e2_ep.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: R7FA2E2A7 Renesas
  pack: Renesas.RA_DFP.3.4.0
  cpu: CPUTYPE("Cortex-M23") noFPU2 CLOCK(12000000) ELITTLE
  output: freertos_ek_ra2e2_ep +hex
  c flags: Optim=3 OneElfS=1 v6Lang=3 v6LangP=3
  c misc: @via/rasc_armclang.via
  library: MicroLIB
  scatter file: .\script\fsp.scat
  link misc: --entry=Reset_Handler --no_startup --via=via/rasc_armlink.via
  group :Renesas RA Smart Configurator:Common Sources
    ./src/: hal_entry.c common_utils.h freertos_ep.h gpt_timer_initialize.c gpt_timer_initialize.h receiver_task_entry.c semaphore_task_entry.c sender_task_entry.c
    ./src/SEGGER_RTT/: SEGGER_RTT.c SEGGER_RTT.h SEGGER_RTT_Conf.h SEGGER_RTT_printf.c
software components: Flex Software:RA Configuration 1.0.0
